# Keil uVision project ATK_RECORDER.uvprojx, settings and files
target ATK_RECORDER (6230000::V6.23::ARMCLANG)
  device: STM32L496VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ATK_RECORDER
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx
  c include: ..\USER;..\CORE;..\HALLIB\STM32L4xx_HAL_Driver\Inc;..\HALLIB\STM32L4xx_HAL_Driver\Inc\Legacy;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\EXTI;..\HARDWARE\IWDG;..\HARDWARE\WWDG;..\HARDWARE\TIMER;..\HARDWARE\PWM;..\HARDWARE\LCD;..\HARDWARE\SPI3;..\USMART;..\HARDWARE\RTC;..\HARDWARE\RNG;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\RECEPTION;..\HARDWARE\EMISSION;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\HARDWARE\STMFLASH;..\HARDWARE\MALLOC;..\HARDWARE\SPI1;..\HARDWARE\SD_CARD;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\APP;..\AUDIOCODEC\wav;..\HARDWARE\SAI;..\HARDWARE\ES8388;..\HARDWARE\MYIIC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32l4xx_it.c system_stm32l4xx.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32l496xx.s
  group HALLIB
    ../HALLIB/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/usart/: usart.c usart.h
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/BEEP/: beep.c beep.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/LCD/: lcd.c lcd.h
    ../HARDWARE/SPI3/: spi3.c spi3.h
    ../HARDWARE/QSPI/: qspi.c qspi.h
    ../HARDWARE/W25QXX/: w25qxx.c w25qxx.h
    ../HARDWARE/STMFLASH/: stmflash.c stmflash.h
    ../HARDWARE/MALLOC/: malloc.c malloc.h
    ../HARDWARE/SPI1/: spi1.c spi1.h
    ../HARDWARE/SD_CARD/: sd_card.c sd_card.h
    ../HARDWARE/SAI/: sai.c sai.h
    ../HARDWARE/ES8388/: es8388.c es8388.h
    ../HARDWARE/MYIIC/: myiic.c myiic.h
  group USMART
    ../USMART/: usmart.c usmart.h usmart_config.c usmart_str.c usmart_str.h
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c fontupd.h text.c text.h
  group AUDIOCODEC
    ../AUDIOCODEC/wav/: wavplay.c wavplay.h
  group APP
    ../APP/: audioplay.c audioplay.h recorder.c recorder.h
  group README
    ../: readme.txt
